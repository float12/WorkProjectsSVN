# IAR project Project.ewp, settings and files
configuration manufactor_zte (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F091; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCDiagSuppress: Pe177,Pe550,Pe767,Pe186,Pa039,pa082
  ICCARM.CCIncludePath2: ..\..\app\CommAPI\; ..\..\app\config\; ..\..\app\system\; ..\..\app\SpecialUser\; ..\..\app\Module\; ..\..\app\Module\para\; ..\..\app\system\ASSERT\; ..\..\app\system\board\; ..\..\app\system\board\ThreeMeter\; ..\..\app\system\board\SingleMeter\; ..\..\app\system\cpu\; ..\..\app\system\Flag\; ..\..\app\system\memory\; ..\..\app\system\sysEvent\; ..\..\app\system\Version\; ..\..\app\system\cpu\HT6025\; ..\..\app\system\cpu\HT6025\Libraries\; ..\..\app\system\cpu\TI5438\; ..\..\app\Module\Energy\; ..\..\app\Module\Demand\; ..\..\app\Module\lcd\; ..\..\app\Module\LoadProfile\; ..\..\app\Module\Prepay\; ..\..\app\Module\syswatch\; ..\..\app\Module\SaveMem\; ..\..\app\Module\sample\; ..\..\app\Module\freeze\; ..\..\app\Module\events\; ..\..\app\Module\events\ProgramRecord\; ..\..\app\Module\protocol\; ..\..\app\Module\lowpower\; ..\..\app\Module\RTC\; ..\..\app\Module\sample\ATT7026E\; ..\..\app\Module\sample\Rn8209\; ..\..\app\Module\protocol\dlt645\; ..\..\app\Module\protocol\dlt698\; ..\..\app\Module\events\InstantEvents\; ..\..\app\Module\events\PrgEvents\; ..\..\app\Module\events\StaticEvents\; ..\..\app\Module\PrePay\GuoWang698\; ..\..\app\Module\Events\Report; ..\..\app\Module\Sample\7053D; ..\..\app\Module\MCollect
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\app\CommAPI\; ..\..\app\config\; ..\..\app\system\; ..\..\app\SpecialUser\; ..\..\app\Module\; ..\..\app\system\ASSERT\; ..\..\app\system\board\; ..\..\app\system\cpu\; ..\..\app\system\Flag\; ..\..\app\system\memory\; ..\..\app\system\sysEvent\; ..\..\app\system\Version\; ..\..\app\system\cpu\HT6025\; ..\..\app\system\cpu\HT6025\Libraries\; ..\..\app\system\cpu\TI5438\; ..\..\app\Module\Energy\; ..\..\app\Module\Demand\; ..\..\app\Module\lcd\; ..\..\app\Module\LoadProfile\; ..\..\app\Module\Prepay\; ..\..\app\Module\syswatch\; ..\..\app\Module\save\; ..\..\app\Module\sample\; ..\..\app\Module\freeze\; ..\..\app\Module\events\; ..\..\app\Module\protocol\; ..\..\app\Module\lowpower\; ..\..\app\Module\RTC\; ..\..\app\Module\sample\ATT7026E\; ..\..\app\Module\sample\Rn8209\; ..\..\app\Module\protocol\dlt645\; ..\..\app\Module\events\AutoWarn\; ..\..\app\Module\events\InstantEvents\; ..\..\app\Module\events\PrgEvents\; ..\..\app\Module\events\StaticEvents\; ..\..\app\Module\Sample\HT7053D
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: ..\..\app\system\cpu\HT6025\HT6025.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app/CommAPI
    ../../app/CommAPI/: CommFunc.c
  group app/config
    ../../app/config/: DefaultConstPara_3Phase.c DefaultConstPara_single.c
  group app/Module/Demand
    ../../app/Module/Demand/: demand.c demand_2022.c
  group app/Module/Energy
    ../../app/Module/Energy/: Energy.c
  group app/Module/Events
    ../../app/Module/Events/: event.c
  group app/Module/Events/InstantEvents
    ../../app/Module/Events/InstantEvents/: BackpropOverload.c Cosover.c Cover.c DemandOver.c DeviceErr.c LostAllV.c LostPower.c magnetic.c PowerErr.c RelayErrEvent.c ReversalUnBalance.c SPIUnBalance.c VICorrelate.c
  group app/Module/Events/ProgramRecord
    ../../app/Module/Events/ProgramRecord/: PrgRecord.c
  group app/Module/Events/Report
    ../../app/Module/Events/Report/: Report645.c Report698.c
  group app/Module/Events/StaticEvents
    ../../app/Module/Events/StaticEvents/: Statistics_Voltage.c
  group app/Module/Freeze
    ../../app/Module/Freeze/: Freeze.c Freeze645.c
  group app/Module/LCD
    ../../app/Module/Lcd/: BU9792.c BU97950.c Lcd_GW3Phase09_M8.C Lcd_HT_SINGLE.C
  group app/Module/MCollect
    ../../app/Module/MCollect/: Link_Collect.c MCollect.h MCollect_Api.h Proc_Collect.c
  group app/Module/para
    ../../app/Module/Para/: para.c
  group app/Module/prepay/GuoWang698
    ../../app/Module/PrePay/GuoWang698/: Card.c Lib_PrePay.c Link_PrePay.c Money.c PrePay.c Relay_Local.c Relay_Remote.c RemotePrePay.c
  group app/Module/Protocol
    ../../app/Module/protocol/: FactoryPro645.c Protocol.c SearchCollectMeter.c SearchCollectMeter_API.h
  group app/Module/Protocol/dlt645
    ../../app/Module/protocol/dlt645/: Demand645.c Dlt645_2007.h dlt645_2007_API.h dlt645_2007APP.c dlt645_2007APPData.c dlt645_2007Link.c dlt645_2007Set_14H.c Energy645.c event645.c ParaMeter645.c Record645.c Variable645.c
  group app/Module/Protocol/dlt698
    ../../app/Module/protocol/DLT698/: Demand698.c Dlt698_45_APP.c DLT698_45APPData.c Dlt698LinkData.c Energy698.c Other698.c ParaMeter698.c Record698.c Variable698.c
  group app/Module/RTC
    ../../app/Module/RTC/: RTC8025T.c RTC_ht_inclock.c timefunc.c
  group app/Module/Sample
    ../../app/Module/Sample/: AHour.c
  group app/Module/Sample/HT7038
    ../../app/Module/Sample/HT7038/: Link_HT7038.c Proc_HT7038.c Proc_HT7038_Adj.c
  group app/Module/Sample/HT7053D
    ../../app/Module/Sample/HT7053D/: HT7053D.h Link_HT7053D.c Proc_HT7053D.c Proc_HT7053D_Adj.c
  group app/Module/SaveMem
    ../../app/Module/SaveMem/: 24LC256.c exteeprom.c gd25q64c.c SaveMem.c
  group app/Module/syswatch
    ../../app/Module/SysWatch/: syswatch.c
  group app/system
    ../../app/system/: main.c
  group app/system/ASSERT
    ../../app/system/ASSERT/: assert.c
  group app/system/board
    ../../app/system/board/: board.c
    ../../app/system/board/SingleMeter/: HT_LowPower_Single.c
    ../../app/system/board/ThreeMeter/: HT_LowPower_Three.c
  group app/system/CPU
    ../../app/system/cpu/: cpu.c
    ../../app/system/cpu/HT6025/: cpuHT6025.c startup_ht6x2x.s
  group app/system/CPU/Libraries
    ../../app/system/cpu/HT6025/Libraries/: ht6xxx_aes&rand.c ht6xxx_cmu.c ht6xxx_flash.c
  group app/system/Flag
    ../../app/system/Flag/: Flag.c
  group app/system/memory
    ../../app/system/memory/: memory.c
  group app/system/sysEvent
    ../../app/system/sysEvent/: sysEvent.c
  group app/system/Version
    ../../app/system/version/: SysDescribe.c
