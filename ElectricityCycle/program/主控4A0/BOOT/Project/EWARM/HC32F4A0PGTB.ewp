# IAR project HC32F4A0PGTB.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: HC32F460KETA HDSC HC32F460KETA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: HC32F4A0; USE_DEVICE_DRIVER_LIB
  ICCARM.CCDiagSuppress: Pe177,Pe550,Pe767,Pe186,Pa039,pa082
  ICCARM.CCIncludePath2: ..\..\common; ..\source; ..\..\app\CommAPI\; ..\..\app\config\; ..\..\app\system\; ..\..\app\SpecialUser\; ..\..\app\Module\; ..\..\app\Module\para\; ..\..\app\system\ASSERT\; ..\..\app\system\board\; ..\..\app\system\cpu\; ..\..\app\system\Flag\; ..\..\app\system\memory\; ..\..\app\system\sysEvent\; ..\..\app\system\Version\; ..\..\app\system\cpu\TI5438\; ..\..\app\Module\Energy\; ..\..\app\Module\Demand\; ..\..\app\Module\lcd\; ..\..\app\Module\LoadProfile\; ..\..\app\Module\Prepay\; ..\..\app\Module\syswatch\; ..\..\app\Module\SaveMem\; ..\..\app\Module\sample\; ..\..\app\Module\freeze\; ..\..\app\Module\events\; ..\..\app\Module\events\ProgramRecord\; ..\..\app\Module\protocol\; ..\..\app\Module\lowpower\; ..\..\app\Module\RTC\; ..\..\app\Module\sample\ATT7026E\; ..\..\app\Module\sample\Rn8209\; ..\..\app\Module\protocol\dlt645\; ..\..\app\Module\protocol\dlt698\; ..\..\app\Module\events\InstantEvents\; ..\..\app\Module\events\PrgEvents\; ..\..\app\Module\events\StaticEvents\; ..\..\app\Module\PrePay\GuoWang698\; ..\..\app\Module\Events\Report; ..\..\app\Module\protocol\OneWire; ..\..\app\Module\protocol\Modbus; ..\..\app\Module\Topology; ..\..\app\Module\MCollect; ..\..\app\system\cpu\HC32F4A0\Libraries; ..\..\app\system\cpu\HC32F4A0; ..\..\app\system\board\SeparateType
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hc32f4a0PGTB.bin
  ILINK.IlinkOutputFile: hc32f4a0pgtb.out
  ILINK.IlinkIcfFile: ..\..\app\system\cpu\HC32F4A0\HC32F4A0xI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: HC32F460
  ICCARM.CCIncludePath2: ..\..\common; ..\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: hc32f460keta.srec
  ILINK.IlinkOutputFile: hc32f460keta.out
  ILINK.IlinkIcfFile: config\HC32F460xE.icf
  group App
    ../../app/system/: __def.h AllHead.h main.c
  group App/CommAPI
    ../../app/CommAPI/: CommFunc.c
  group App/config
    ../../app/config/: DefaultConstPara_Sperate.h relation.h sys.h
  group App/Module/SaveMem
    ../../app/Module/SaveMem/: exteeprom.c gd25q64c.c gd25q64c.h savemem_API.h
  group App/System/Board
    ../../app/system/board/: board.c board_API.h
  group App/System/cpu
    ../../app/system/cpu/: cpu.c cpu_API.h
  group App/System/cpu/HC32F4A0
    ../../app/system/cpu/HC32F4A0/: cpuHC32F4A0.c startup_hc32f4a0.s
    ../../app/system/cpu/HC32F4A0/Libraries/: system_hc32f4a0.c
  group App/System/cpu/HC32F4A0/Libraries
    ../../app/system/cpu/HC32F4A0/Libraries/: bsp_cpu_flash.c bsp_cpu_flash.h core_cm4.h hc32_common.h hc32_ddl.h hc32_ll.c hc32_ll.h hc32_ll_adc.c hc32_ll_adc.h hc32_ll_aes.c hc32_ll_aes.h hc32_ll_aos.c hc32_ll_aos.h hc32_ll_can.c hc32_ll_can.h hc32_ll_clk.c hc32_ll_clk.h hc32_ll_cmp.c hc32_ll_cmp.h hc32_ll_crc.c hc32_ll_crc.h hc32_ll_ctc.c hc32_ll_ctc.h hc32_ll_dac.c hc32_ll_dac.h hc32_ll_dbgc.c hc32_ll_dbgc.h hc32_ll_dcu.c hc32_ll_dcu.h hc32_ll_def.h hc32_ll_dma.c hc32_ll_dma.h hc32_ll_dmc.c hc32_ll_dmc.h hc32_ll_dvp.c hc32_ll_dvp.h hc32_ll_efm.c hc32_ll_efm.h hc32_ll_emb.c hc32_ll_emb.h hc32_ll_eth.c hc32_ll_eth.h hc32_ll_event_port.c hc32_ll_event_port.h hc32_ll_fcg.c hc32_ll_fcg.h hc32_ll_fcm.c hc32_ll_fcm.h hc32_ll_fmac.c hc32_ll_fmac.h hc32_ll_gpio.c hc32_ll_gpio.h hc32_ll_hash.c hc32_ll_hash.h hc32_ll_hrpwm.c hc32_ll_hrpwm.h hc32_ll_i2c.c hc32_ll_i2c.h hc32_ll_i2s.c hc32_ll_i2s.h hc32_ll_icg.c hc32_ll_icg.h hc32_ll_interrupts.c hc32_ll_interrupts.h hc32_ll_keyscan.c hc32_ll_keyscan.h hc32_ll_mau.c hc32_ll_mau.h hc32_ll_mpu.c hc32_ll_mpu.h hc32_ll_nfc.c hc32_ll_nfc.h hc32_ll_ots.c hc32_ll_ots.h hc32_ll_pwc.c hc32_ll_pwc.h hc32_ll_qspi.c hc32_ll_qspi.h hc32_ll_rmu.c hc32_ll_rmu.h hc32_ll_rtc.c hc32_ll_rtc.h hc32_ll_sdioc.c hc32_ll_sdioc.h hc32_ll_smc.c hc32_ll_smc.h hc32_ll_spi.c hc32_ll_spi.h hc32_ll_sram.c hc32_ll_sram.h hc32_ll_swdt.c hc32_ll_swdt.h hc32_ll_tmr0.c hc32_ll_tmr0.h hc32_ll_tmr2.c hc32_ll_tmr2.h hc32_ll_tmr4.c hc32_ll_tmr4.h hc32_ll_tmr6.c hc32_ll_tmr6.h hc32_ll_tmra.c hc32_ll_tmra.h hc32_ll_trng.c hc32_ll_trng.h hc32_ll_usart.c hc32_ll_usart.h hc32_ll_usb.c hc32_ll_usb.h hc32_ll_utility.c hc32_ll_utility.h hc32_ll_wdt.c hc32_ll_wdt.h hc32f4a0.h hc32f4a0_ll_interrupts_share.c hc32f4a0_ll_interrupts_share.h SimulateSci.c SimulateSci.h system_hc32f4a0.h
