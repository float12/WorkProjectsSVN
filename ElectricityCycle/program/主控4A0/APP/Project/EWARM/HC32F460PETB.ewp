# IAR project HC32F460PETB.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: HC32F460KETA HDSC HC32F460KETA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: HC32F4A0; USE_DEVICE_DRIVER_LIB
  ICCARM.CCDiagSuppress: Pe177,Pe550,Pe767,Pe186,Pa039,pa082
  ICCARM.CCIncludePath2: ..\..\common; ..\source; ..\..\app\CommAPI\; ..\..\app\config\; ..\..\app\system\; ..\..\app\SpecialUser\; ..\..\app\Module\; ..\..\app\Module\para\; ..\..\app\system\ASSERT\; ..\..\app\system\board\; ..\..\app\system\cpu\; ..\..\app\system\Flag\; ..\..\app\system\memory\; ..\..\app\system\sysEvent\; ..\..\app\system\Version\; ..\..\app\Module\Energy\; ..\..\app\Module\Demand\; ..\..\app\Module\lcd\; ..\..\app\Module\LoadProfile\; ..\..\app\Module\Prepay\; ..\..\app\Module\syswatch\; ..\..\app\Module\SaveMem\; ..\..\app\Module\sample\; ..\..\app\Module\freeze\; ..\..\app\Module\events\; ..\..\app\Module\events\ProgramRecord\; ..\..\app\Module\protocol\; ..\..\app\Module\lowpower\; ..\..\app\Module\RTC\; ..\..\app\Module\protocol\dlt645\; ..\..\app\Module\protocol\dlt698\; ..\..\app\Module\events\InstantEvents\; ..\..\app\Module\events\PrgEvents\; ..\..\app\Module\events\StaticEvents\; ..\..\app\Module\PrePay\GuoWang698\; ..\..\app\Module\Events\Report; ..\..\app\Module\protocol\Modbus; ..\..\app\system\cpu\HC32F4A0; ..\..\app\system\cpu\HC32F4A0\Libraries; ..\..\app\Module\Sample\HT7038; ..\..\app\system\board\ThreeMeter; ..\..\app\Module\Lcd; ..\..\app\mid; ..\..\app\Module\Sample\RN8302B; ..\..\app\Module\protocol\CanBus; ..\..\app\Module\Sample\LSXQ; ..\..\app\Module\MCollect; ..\..\app\Module\MCollect\flatInc; ..\..\app\Module\MCollect\appInc; ..\..\app\Module\Dbase; ..\..\app\Module\BlueTooth; ..\..\app\mid\ExpH; ..\..\app\Module\Topology; ..\..\app\Module; ..\..\app\Module\WaveRecord\SDIO; ..\..\app\Module\WaveRecord\FatFs_R0.09\src; ..\..\app\Module\WaveRecord; ..\..\app\Module\WaveRecord\SDIO\sd_card\inc; ..\..\app\Module\WaveRecord\SPI; ..\..\app\SEGGER_RTT_V820
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\app\Module\mid
  OBJCOPY.OOCOutputFile: HC32F460PETB.bin
  ILINK.IlinkOutputFile: hc32f460keta.out
  ILINK.IlinkConfigDefines: _LINK_FLASH_= 0; _HC32F4A0_2M_= 1
  ILINK.IlinkIcfFile: ..\..\app\system\cpu\HC32F4A0\HC32F4A0xI.icf
  ILINK.IlinkAdditionalLibs: ..\..\app\mid\mid.lib; ..\..\app\mid\ModuleA.lib; ..\..\app\Module\Topology\TopLib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: HC32F460
  ICCARM.CCIncludePath2: ..\..\common; ..\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: hc32f460keta.srec
  ILINK.IlinkIcfFile: config\HC32F460xE.icf
  group App
    ../../app/system/: __def.h AllHead.h main.c
  group App/CommAPI
    ../../app/CommAPI/: CommFunc.c CommFunc_API.h
  group App/config
    ../../app/config/: Config_3Phase_Meter.h ConstConfig.h DefaultConstPara_3Phase.c relation.h Specialuser.h sys.h
  group App/Mid
    ../../app/mid/: _defA.h mid.h mid.lib Mid_api.c Mid_api.h MidLayer.c MidLayerApi.h ModuleA.lib
  group App/Mid/Exp
    ../../app/mid/ExpH/: _defA.h FlagA.h MidPort.h ProtocolA.h
  group App/Module/Dbase
    ../../app/Module/Dbase/: DI.c DI_Api.h
  group App/Module/Demand
    ../../app/Module/Demand/: demand.c demand_2022.c demand_2022_Api.h demand_Api.h
  group App/Module/Energy
    ../../app/Module/Energy/: Energy.c Energy_API.h
  group App/Module/Event
    ../../app/Module/Events/: event.c event.h event_Api.h
  group App/Module/Event/InstandEvents
    ../../app/Module/Events/InstantEvents/: BackpropOverload.c BackpropOverload.h Cosover.c cosover.h Cover.c Cover.h DemandOver.c DemandOver.h DeviceErr.c DeviceErr.h LostAllV.c LostAllV.h LostPower.c LostPower.h magnetic.c Magnetic.h PowerErr.c PowerErr.h RelayErrEvent.c RelayErrEvent.h ReversalUnBalance.c ReversalUnBalance.h Rogowski.c Rogowski.h SPIUnBalance.c spiUnBalance.h VICorrelate.c VICorrelate.h
  group App/Module/Event/ProgramRecord
    ../../app/Module/Events/ProgramRecord/: PrgRecord.c PrgRecord.h
  group App/Module/Event/Report
    ../../app/Module/Events/Report/: Report645.c Report645_Api.h Report698.c Report698_Api.h
  group App/Module/Event/StaticEvents
    ../../app/Module/Events/StaticEvents/: Statistics_Voltage.c statistics_voltage.h
  group App/Module/Freeze
    ../../app/Module/Freeze/: Freeze.c Freeze.h Freeze645.c Freeze_API.h
  group App/Module/Lcd
    ../../app/Module/Lcd/: lcd_API.h Lcd_HT_NO.C
  group App/Module/MCollect
    ../../app/Module/MCollect/: Link_Collect.c Proc_Collect.c root.c
  group App/Module/MCollect/DLT64507
    ../../app/Module/MCollect/DLT64507/: mdlt645_2007.c mdlt645fun.c
  group App/Module/MCollect/GDW698
    ../../app/Module/MCollect/GDW698/: GDW698_PARA.c GDW698Base.c GDW698Funcs.c
  group App/Module/MCollect/GDW698/Class
    ../../app/Module/MCollect/GDW698/Class/: Class11_set.c Classx_funcs.c
  group App/Module/MCollect/GDW698/Client
    ../../app/Module/MCollect/GDW698/Client/: MGDW698.c
  group App/Module/MCollect/GDW698/DBase/para
    ../../app/Module/MCollect/GDW698/DBase/para/: syscfg_698.c
  group App/Module/MCollect/guiyue
    ../../app/Module/MCollect/guiyue/: cgy.c gyFuncs.c
  group App/Module/MCollect/Os
    ../../app/Module/MCollect/Os/: file.c func.c time.c
  group App/Module/MCollect/sys
    ../../app/Module/MCollect/sys/: dbfun.c initmps.c initsystem.c mp.c mpflags.c system.c
  group App/Module/Para
    ../../app/Module/Para/: para.c para_API.h
  group App/Module/PrePay
    ../../app/Module/PrePay/GuoWang698/: Card.c Lib_PrePay.c Link_PrePay.c Money.c PrePay.c PrePay.h Relay_Local.c Relay_Local_API.h Relay_Remote.c Relay_Remote_API.h RemotePrePay.c
  group App/Module/Protocol
    ../../app/Module/protocol/: FactoryPro645.c Protocol.c Protocol.h SearchCollectMeter.c
  group App/Module/Protocol/CanBus
    ../../app/Module/protocol/CanBus/: CanBus.c
  group App/Module/Protocol/dlt645
    ../../app/Module/protocol/dlt645/: Demand645.c Dlt645_2007.h dlt645_2007_API.h dlt645_2007APP.c dlt645_2007APPData.c dlt645_2007Link.c dlt645_2007Set_14H.c Energy645.c event645.c ParaMeter645.c Record645.c Variable645.c
  group App/Module/Protocol/dlt698
    ../../app/Module/protocol/DLT698/: Demand698.c Dlt698_45.h Dlt698_45_API.h Dlt698_45_APP.c DLT698_45APPData.c Dlt698LinkData.c Energy698.c Other698.c ParaMeter698.c Record698.c Variable698.c
  group App/Module/rtc
    ../../app/Module/RTC/: RTC8025T.c RTC_API.h RTC_ht_inclock.c timefunc.c
  group App/Module/Sample
    ../../app/Module/Sample/: AHour.c
    ../../app/Module/Sample/RN8302B/: arm_math.h Link_RN8302B.c Proc_RN8302B.c Proc_RN8302B_Adj.c RN8302B.h
  group App/Module/SaveMem
    ../../app/Module/SaveMem/: 24LC256.c exteeprom.c gd25q64c.c gd25q64c.h SaveMem.c SaveMem.h savemem_API.h SaveMemM.h
  group App/Module/SysWatch
    ../../app/Module/SysWatch/: syswatch.c syswatch_API.h
  group App/Module/Topology
    ../../app/Module/Topology/: topo_API.h topoApp.c topoApp.h
  group App/Module/WaveRecord
    ../../app/Module/WaveRecord/: WaveRxTx.c
  group App/rtt
    ../../app/SEGGER_RTT_V820/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
    ../../app/SEGGER_RTT_V820/RTT/: SEGGER_RTT.h
    ../../app/SEGGER_RTT_V820/Config/: SEGGER_RTT_Conf.h
  group App/System/ASSERT
    ../../app/system/ASSERT/: assert.c assert_API.h
  group App/System/Board
    ../../app/system/board/: board.c board_API.h
    ../../app/system/board/ThreeMeter/: F4A0_LowPower_Three.c
  group App/System/cpu/HC32F4A0
    ../../app/system/cpu/: cpu.c cpu_API.h
    ../../app/system/cpu/HC32F4A0/: cpuHC32F4A0.c startup_hc32f4a0.s
  group App/System/cpu/HC32F4A0/libraries
    ../../app/system/cpu/HC32F4A0/Libraries/: bsp_cpu_flash.c bsp_cpu_flash.h core_cm4.h hc32_common.h hc32_ddl.h hc32_ll.c hc32_ll.h hc32_ll_adc.c hc32_ll_adc.h hc32_ll_aes.c hc32_ll_aes.h hc32_ll_aos.c hc32_ll_aos.h hc32_ll_can.c hc32_ll_can.h hc32_ll_clk.c hc32_ll_clk.h hc32_ll_cmp.c hc32_ll_cmp.h hc32_ll_crc.c hc32_ll_crc.h hc32_ll_ctc.c hc32_ll_ctc.h hc32_ll_dac.c hc32_ll_dac.h hc32_ll_dbgc.c hc32_ll_dbgc.h hc32_ll_dcu.c hc32_ll_dcu.h hc32_ll_def.h hc32_ll_dma.c hc32_ll_dma.h hc32_ll_dmc.c hc32_ll_dmc.h hc32_ll_dvp.c hc32_ll_dvp.h hc32_ll_efm.c hc32_ll_efm.h hc32_ll_emb.c hc32_ll_emb.h hc32_ll_eth.c hc32_ll_eth.h hc32_ll_event_port.c hc32_ll_event_port.h hc32_ll_fcg.c hc32_ll_fcg.h hc32_ll_fcm.c hc32_ll_fcm.h hc32_ll_fmac.c hc32_ll_fmac.h hc32_ll_gpio.c hc32_ll_gpio.h hc32_ll_hash.c hc32_ll_hash.h hc32_ll_hrpwm.c hc32_ll_hrpwm.h hc32_ll_i2c.c hc32_ll_i2c.h hc32_ll_i2s.c hc32_ll_i2s.h hc32_ll_icg.c hc32_ll_icg.h hc32_ll_interrupts.c hc32_ll_interrupts.h hc32_ll_keyscan.c hc32_ll_keyscan.h hc32_ll_mau.c hc32_ll_mau.h hc32_ll_mpu.c hc32_ll_mpu.h hc32_ll_nfc.c hc32_ll_nfc.h hc32_ll_ots.c hc32_ll_ots.h hc32_ll_pwc.c hc32_ll_pwc.h hc32_ll_qspi.c hc32_ll_qspi.h hc32_ll_rmu.c hc32_ll_rmu.h hc32_ll_rtc.c hc32_ll_rtc.h hc32_ll_sdioc.c hc32_ll_sdioc.h hc32_ll_smc.c hc32_ll_smc.h hc32_ll_spi.c hc32_ll_spi.h hc32_ll_sram.c hc32_ll_sram.h hc32_ll_swdt.c hc32_ll_swdt.h hc32_ll_tmr0.c hc32_ll_tmr0.h hc32_ll_tmr2.c hc32_ll_tmr2.h hc32_ll_tmr4.c hc32_ll_tmr4.h hc32_ll_tmr6.c hc32_ll_tmr6.h hc32_ll_tmra.c hc32_ll_tmra.h hc32_ll_trng.c hc32_ll_trng.h hc32_ll_usart.c hc32_ll_usart.h hc32_ll_usb.c hc32_ll_usb.h hc32_ll_utility.c hc32_ll_utility.h hc32_ll_wdt.c hc32_ll_wdt.h hc32f4a0.h hc32f4a0_ll_interrupts_share.c hc32f4a0_ll_interrupts_share.h SimulateSci.c SimulateSci.h system_hc32f4a0.c system_hc32f4a0.h
  group App/System/flag
    ../../app/system/Flag/: Flag.c flag_API.h
  group App/System/memory
    ../../app/system/memory/: memory.c memory_API.h
  group App/System/sysEvent
    ../../app/system/sysEvent/: sysEvent.c sysEvent_API.h
  group App/System/Version
    ../../app/system/version/: SysDescribe.c SysDescribe.h
