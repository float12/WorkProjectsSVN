# IAR project HC32F460PETB.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: HC32F460; USE_DEVICE_DRIVER_LIB
  ICCARM.CCDiagSuppress: Pe177,Pe550,Pe767,Pe186,Pa039,pa082
  ICCARM.CCIncludePath2: ..\..\common; ..\source; ..\..\app\CommAPI\; ..\..\app\config\; ..\..\app\system\; ..\..\app\SpecialUser\; ..\..\app\Module\; ..\..\app\Module\para\; ..\..\app\system\ASSERT\; ..\..\app\system\board\; ..\..\app\system\cpu\; ..\..\app\system\Flag\; ..\..\app\system\memory\; ..\..\app\system\sysEvent\; ..\..\app\system\Version\; ..\..\app\Module\Energy\; ..\..\app\Module\Demand\; ..\..\app\Module\lcd\; ..\..\app\Module\LoadProfile\; ..\..\app\Module\Prepay\; ..\..\app\Module\syswatch\; ..\..\app\Module\SaveMem\; ..\..\app\Module\sample\; ..\..\app\Module\freeze\; ..\..\app\Module\events\ProgramRecord\; ..\..\app\Module\protocol\; ..\..\app\Module\lowpower\; ..\..\app\Module\RTC\; ..\..\app\Module\protocol\dlt645\; ..\..\app\Module\protocol\dlt698\; ..\..\app\Module\events\InstantEvents\; ..\..\app\Module\events\PrgEvents\; ..\..\app\Module\events\StaticEvents\; ..\..\app\Module\PrePay\GuoWang698\; ..\..\app\Module\Events\Report; ..\..\app\Module\protocol\Modbus; ..\..\app\system\cpu\HC32F460\Libraries; ..\..\app\system\cpu\HC32F460; ..\..\app\Module\Sample\HT7038; ..\..\app\system\board\ThreeMeter; ..\..\app\Module\Lcd; ..\..\app\mid; ..\..\app\Module\Sample\RN8302B; ..\..\app\Module\protocol\CanBus; ..\..\app\Module\Sample\LSXQ; ..\..\app\Module\MCollect; ..\..\app\Module\MCollect\flatInc; ..\..\app\Module\MCollect\appInc; ..\..\app\Module\Dbase; ..\..\app\Module\BlueTooth; ..\..\app\mid\ExpH; ..\..\app\Module\Topology; ..\..\app\Module; ..\..\app\Module\WaveRecord\SDIO; ..\..\app\Module\WaveRecord\FatFs_R0.09\src; ..\..\app\Module\WaveRecord; ..\..\app\Module\WaveRecord\SDIO\sd_card\inc; ..\..\app\Module\WaveRecord\SPI; ..\..\app\SEGGER_RTT_V820
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\app\Module\mid
  OBJCOPY.OOCOutputFile: HC32F460PETB.bin
  ILINK.IlinkOutputFile: hc32f460keta.out
  ILINK.IlinkIcfFile: ..\..\app\system\cpu\HC32F460\HC32F46x - 副本.icf
  ILINK.IlinkAdditionalLibs: ..\..\app\mid\mid.lib; ..\..\app\mid\ModuleA.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  ICCARM.CCDefines: HC32F460
  ICCARM.CCIncludePath2: ..\..\common; ..\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: hc32f460keta.srec
  ILINK.IlinkIcfFile: F:\project\waveRecord\program\APP\app\system\cpu\HC32F460\HC32F46x - 副本.icf
  group App
    ../../app/system/: __def.h AllHead.h main.c
  group App/CommAPI
    ../../app/CommAPI/: CommFunc.c CommFunc_API.h
  group App/config
    ../../app/config/: Config_3Phase_Meter.h ConstConfig.h DefaultConstPara_3Phase.c relation.h Specialuser.h sys.h
  group App/Mid
    ../../app/mid/: _defA.h mid.h mid.lib Mid_api.c Mid_api.h MidLayer.c MidLayerApi.h ModuleA.lib
  group App/Mid/Exp
    ../../app/mid/ExpH/: _defA.h FlagA.h MidPort.h ProtocolA.h
  group App/Module/Dbase
    ../../app/Module/Dbase/: DI.c DI_Api.h
  group App/Module/Demand
    ../../app/Module/Demand/: demand.c demand_2022.c demand_2022_Api.h demand_Api.h
  group App/Module/Energy
    ../../app/Module/Energy/: Energy.c Energy_API.h
  group App/Module/Lcd
    ../../app/Module/Lcd/: lcd_API.h Lcd_HT_NO.C
  group App/Module/Para
    ../../app/Module/Para/: para.c para_API.h
  group App/Module/PrePay
    ../../app/Module/PrePay/GuoWang698/: Card.c Lib_PrePay.c Link_PrePay.c Money.c PrePay.c PrePay.h Relay_Local.c Relay_Local_API.h Relay_Remote.c Relay_Remote_API.h RemotePrePay.c
  group App/Module/Protocol
    ../../app/Module/protocol/: FactoryPro645.c Protocol.c Protocol.h SearchCollectMeter.c
  group App/Module/Protocol/dlt645
    ../../app/Module/protocol/dlt645/: Demand645.c Dlt645_2007.h dlt645_2007_API.h dlt645_2007APP.c dlt645_2007APPData.c dlt645_2007Link.c dlt645_2007Set_14H.c Energy645.c event645.c ParaMeter645.c Record645.c Variable645.c
  group App/Module/Protocol/dlt698
    ../../app/Module/protocol/DLT698/: Demand698.c Dlt698_45.h Dlt698_45_API.h Dlt698_45_APP.c DLT698_45APPData.c Dlt698LinkData.c Energy698.c Other698.c ParaMeter698.c Record698.c Variable698.c
  group App/Module/rtc
    ../../app/Module/RTC/: RTC8025T.c RTC_API.h RTC_ht_inclock.c timefunc.c
  group App/Module/Sample
    ../../app/Module/Sample/: AHour.c
    ../../app/Module/Sample/RN8302B/: api_VI.h arm_math.h HarmonicWaveAndVI.c HarmonicWaveAndVI.h Link_RN8302B.c Proc_RN8302B.c Proc_RN8302B_Adj.c RN8302B.h VI.c
  group App/Module/SaveMem
    ../../app/Module/SaveMem/: 24LC256.c exteeprom.c gd25q64c.c gd25q64c.h SaveMem.c SaveMem.h savemem_API.h SaveMemM.h
  group App/Module/SysWatch
    ../../app/Module/SysWatch/: syswatch.c syswatch_API.h
  group App/Module/Topology
    ../../app/Module/Topology/: topo_API.h topoApp.c topoApp.h
  group App/Module/WaveRecord
    ../../app/Module/WaveRecord/: SendWaveData.c SendWaveData.h WaveRecord.c waveRecord.h
  group App/Module/WaveRecord/Fatfs
    ../../app/Module/WaveRecord/FatFs_R0.09/src/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group App/Module/WaveRecord/sdio
    ../../app/Module/WaveRecord/SDIO/sd_card/src/: sd_card.c sdmmc_cmd.c
    ../../app/Module/WaveRecord/SDIO/: SDIO_MSD_Driver.c SDIO_MSD_Driver.h
  group App/rtt
    ../../app/SEGGER_RTT_V820/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
    ../../app/SEGGER_RTT_V820/RTT/: SEGGER_RTT.h
    ../../app/SEGGER_RTT_V820/Config/: SEGGER_RTT_Conf.h
  group App/System/ASSERT
    ../../app/system/ASSERT/: assert.c assert_API.h
  group App/System/Board
    ../../app/system/board/: board.c board_API.h
    ../../app/system/board/ThreeMeter/: F460_LowPower_Three.c
  group App/System/cpu
    ../../app/system/cpu/: cpu.c cpu_API.h
  group App/System/cpu/HC32F460
    ../../app/system/cpu/HC32F460/: cpuHC32F460.c startup_hc32f460keta.s
    ../../app/system/cpu/HC32F460/Libraries/: system_hc32f460.c
  group App/System/cpu/HC32F460/Libraries
    ../../app/system/cpu/HC32F460/Libraries/: bsp_cpu_flash.c core_cm4.h hc32_common.h hc32_ddl.h hc32f460.h hc32f460_adc.c hc32f460_adc.h hc32f460_can.c hc32f460_can.h hc32f460_clk.c hc32f460_clk.h hc32f460_dmac.c hc32f460_efm.c hc32f460_efm.h hc32f460_event_port.c hc32f460_event_port.h hc32f460_exint_nmi_swi.c hc32f460_exint_nmi_swi.h hc32f460_gpio.c hc32f460_gpio.h hc32f460_interrupts.c hc32f460_interrupts.h hc32f460_keyscan.c hc32f460_keyscan.h hc32f460_mpu.c hc32f460_mpu.h hc32f460_ots.c hc32f460_ots.h hc32f460_pwc.c hc32f460_pwc.h hc32f460_rmu.c hc32f460_rmu.h hc32f460_sdioc.c hc32f460_spi.c hc32f460_sram.c hc32f460_timer0.c hc32f460_timera.c hc32f460_timera.h hc32f460_usart.c hc32f460_usart.h hc32f460_utility.c hc32f460_utility.h hc32f460_wdt.c hc32f460_wdt.h system_hc32f460.h
  group App/System/flag
    ../../app/system/Flag/: Flag.c flag_API.h
  group App/System/memory
    ../../app/system/memory/: memory.c memory_API.h
  group App/System/sysEvent
    ../../app/system/sysEvent/: sysEvent.c sysEvent_API.h
  group App/System/Version
    ../../app/system/version/: SysDescribe.c SysDescribe.h
