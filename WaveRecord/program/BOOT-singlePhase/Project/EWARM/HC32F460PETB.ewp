# IAR project HC32F460PETB.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: HC32F460KETA HDSC HC32F460KETA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: HC32F460; USE_DEVICE_DRIVER_LIB
  ICCARM.CCDiagSuppress: Pe177,Pe550,Pe767,Pe186,Pa039,pa082
  ICCARM.CCIncludePath2: ..\..\common; ..\source; ..\..\app\CommAPI\; ..\..\app\config\; ..\..\app\system\; ..\..\app\SpecialUser\; ..\..\app\Module\; ..\..\app\Module\para\; ..\..\app\system\ASSERT\; ..\..\app\system\board\; ..\..\app\system\cpu\; ..\..\app\system\Flag\; ..\..\app\system\memory\; ..\..\app\system\sysEvent\; ..\..\app\system\Version\; ..\..\app\system\cpu\TI5438\; ..\..\app\Module\Energy\; ..\..\app\Module\Demand\; ..\..\app\Module\lcd\; ..\..\app\Module\LoadProfile\; ..\..\app\Module\Prepay\; ..\..\app\Module\syswatch\; ..\..\app\Module\SaveMem\; ..\..\app\Module\sample\; ..\..\app\Module\freeze\; ..\..\app\Module\events\; ..\..\app\Module\events\ProgramRecord\; ..\..\app\Module\protocol\; ..\..\app\Module\lowpower\; ..\..\app\Module\RTC\; ..\..\app\Module\sample\ATT7026E\; ..\..\app\Module\sample\Rn8209\; ..\..\app\Module\protocol\dlt645\; ..\..\app\Module\protocol\dlt698\; ..\..\app\Module\events\InstantEvents\; ..\..\app\Module\events\PrgEvents\; ..\..\app\Module\events\StaticEvents\; ..\..\app\Module\PrePay\GuoWang698\; ..\..\app\Module\Events\Report; ..\..\app\Module\protocol\OneWire; ..\..\app\Module\protocol\Modbus; ..\..\app\Module\Topology; ..\..\app\Module\MCollect; ..\..\app\system\cpu\HC32F460\Libraries; ..\..\app\system\cpu\HC32F460; ..\..\app\system\board\SeparateType
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hc32f460PETB.bin
  ILINK.IlinkOutputFile: hc32f460petb.out
  ILINK.IlinkIcfFile: ..\..\app\system\cpu\HC32F460\HC32F46x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: HC32F460
  ICCARM.CCIncludePath2: ..\..\common; ..\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: hc32f460keta.srec
  ILINK.IlinkOutputFile: hc32f460keta.out
  ILINK.IlinkIcfFile: config\HC32F460xE.icf
  group App
    ../../app/system/: __def.h AllHead.h main.c
  group App/CommAPI
    ../../app/CommAPI/: CommFunc.c
  group App/config
    ../../app/config/: DefaultConstPara_Sperate.h relation.h sys.h
  group App/Module/SaveMem
    ../../app/Module/SaveMem/: exteeprom.c gd25q64c.c gd25q64c.h savemem_API.h
  group App/System/Board
    ../../app/system/board/: board.c board_API.h
  group App/System/cpu
    ../../app/system/cpu/: cpu.c cpu_API.h
  group App/System/cpu/HC32F460
    ../../app/system/cpu/HC32F460/: cpuHC32F460.c startup_hc32f460keta.s
    ../../app/system/cpu/HC32F460/Libraries/: system_hc32f460.c
  group App/System/cpu/HC32F460/Libraries
    ../../app/system/cpu/HC32F460/Libraries/: bsp_cpu_flash.c core_cm4.h hc32_common.h hc32_ddl.h hc32f460.h hc32f460_adc.c hc32f460_adc.h hc32f460_clk.c hc32f460_clk.h hc32f460_efm.c hc32f460_efm.h hc32f460_event_port.c hc32f460_event_port.h hc32f460_gpio.c hc32f460_gpio.h hc32f460_icg.c hc32f460_icg.h hc32f460_interrupts.c hc32f460_interrupts.h hc32f460_mpu.c hc32f460_mpu.h hc32f460_pwc.c hc32f460_pwc.h hc32f460_spi.c hc32f460_sram.c hc32f460_timera.c hc32f460_timera.h hc32f460_utility.c hc32f460_utility.h hc32f460_wdt.c hc32f460_wdt.h system_hc32f460.h
