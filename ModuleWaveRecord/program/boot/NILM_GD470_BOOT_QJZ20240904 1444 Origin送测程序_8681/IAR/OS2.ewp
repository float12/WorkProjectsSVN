# IAR project OS2.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F470
  ICCARM.CCIncludePath2: ..\app\include; ..\app\CommAPI; ..\app\Config; ..\app\Fal; ..\app\Module\Dbase; ..\app\Module\Events; ..\app\Module\Freeze; ..\app\Module\Led; ..\app\Module\Meter; ..\app\Module\Para; ..\app\Module\Protocol; ..\app\Module\Protocol\dlt645; ..\app\Module\Protocol\DLT698; ..\app\Module\SaveMem; ..\app\Module\Time; ..\app\System; ..\app\System\Cpu\GD32F4xx\CMSIS\GD\GD32F4xx\Include; ..\app\System\Cpu\GD32F4xx\GD32F4xx_board; ..\app\System\Cpu\GD32F4xx\GD32F4xx_standard_peripheral\Include; ..\app\System\Flag; ..\app\System\Cpu\GD32F4xx; ..\app\System\Board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NILM_BOOT.bin
  ILINK.IlinkOutputFile: NILM_BOOT.out
  ILINK.IlinkIcfFile: GD32F450.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app/CommAPI
    ../app/CommAPI/: CommFunc.c CommFunc_API.h crc16.c crc16.h
  group app/Config
    ../app/Config/: sys.h
  group app/Module/Dbase
    ../app/Module/Dbase/: dbase.c dbase.h
  group app/Module/Led
    ../app/Module/Led/: LED.c LED.h
  group app/Module/Meter
    ../app/Module/Meter/: main_task.c main_task.h task_update.c task_update.h
  group app/Module/Protocol
    ../app/Module/Protocol/: FactoryPro645.c Protocol.c Protocol.h
  group app/Module/Protocol/DLT645
    ../app/Module/Protocol/dlt645/: dlt645_2007APP.c dlt645_2007APPData.c dlt645_2007Link.c Record645.c
  group app/Module/Protocol/DLT698
    ../app/Module/Protocol/DLT698/: Dlt698_45.h Dlt698_45_API.h Dlt698_45_APP.c DLT698_45APPData.c Dlt698LinkData.c ManageCom.c ParaMeter698.c Record698.c Variable698.c
  group app/Module/SaveMem
    ../app/Module/SaveMem/: gd25q64c.c M24512.c SaveMem.c SaveMem.h savemem_API.h
  group app/Module/Time
    ../app/Module/Time/: dsp_time.c dsp_time.h
  group app/System
    ../app/System/: __def.h AllHead.h main.c main.h
  group app/System/Board/GD32F450
    ../app/System/Board/: board_gd32f450.c
    ../app/System/Cpu/GD32F4xx/: gd32f450v_start.c
    ../app/System/Cpu/GD32F4xx/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f450_470.s
  group app/System/Board/GD32F450/CMSIS
    ../app/System/Cpu/GD32F4xx/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group app/System/Board/GD32F450/GD32F4XX_Driver
    ../app/System/Cpu/GD32F4xx/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group app/System/Cpu
    ../app/System/Cpu/GD32F4xx/: cpustm32f4xx.c gd32f4xx_it.c
    ../app/System/Cpu/GD32F4xx/GD32F4xx_board/: spi.c spi.h systick.c tim.c tim.h usart.c usart.h
  group app/System/Flag
    ../app/System/Flag/: Flag.c flag_API.h
