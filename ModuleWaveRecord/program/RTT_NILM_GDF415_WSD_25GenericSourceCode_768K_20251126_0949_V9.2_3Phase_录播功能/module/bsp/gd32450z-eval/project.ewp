# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F415RIO6 GD GD32F415RIO6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F450; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR; _DLIB_ADD_EXTRA_SYMBOLS; MBEDTLS_CONFIG_FILE=<config-mini-tls1_1.h>
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pa181,Pe181
  ICCARM.CCIncludePath2: ..\..\include; Libraries\GD32F4xx_standard_peripheral\Include; ..\..\libcpu\arm\common; ..\..\components\drivers\include; ..\..\components\dfs\filesystems\devfs; ..\..\components\libc\posix\ipc; drivers; ..\..\components\net\lwip\lwip-2.0.3\src\include\netif; Libraries\CMSIS\GD\GD32F4xx\Include; .; ..\..\components\net\lwip\lwip-2.0.3\src\include; ..\..\libcpu\arm\cortex-m4; Libraries\CMSIS; ..\..\components\net\sal\include\dfs_net; ..\..\components\dfs\include; ..\..\components\libc\compilers\common\include; applications; ..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4; ..\..\components\net\lwip\port; ..\..\components\finsh; ..\..\components\net\sal\include\socket\sys_socket; ..\..\components\dfs\filesystems\elmfat; ..\..\components\libc\compilers\common\extension; ..\..\components\net\sal\include; ..\..\components\net\sal\impl; ..\..\components\net\netdev\include; ..\..\components\libc\posix\io\poll; ..\..\components\libc\posix\io\stdio; ..\..\components\net\sal\include\socket; ..\..\components\dfs\dfs_v1\include; ..\..\app\System; ..\..\app\Config; ..\..\app\CommAPI; ..\..\app\Module\Dbase; ..\..\app\System\Flag; ..\..\app\Module\Time; ..\..\app\Module\Protocol; ..\..\app\Module\Protocol\dlt645; ..\..\app\Module\Protocol\DLT698; ..\..\app\Module\Events; ..\..\app\Module\Freeze; ..\..\app\Module\SaveMem; ..\..\app\Module\Meter; ..\..\app\Fal; ..\..\app\Module\Sample; ..\..\app\System\Cpu\GD32F4xx\GD32F4xx_board; ..\..\app\Module\Led; ..\..\app\System\Board; ..\..\app\System\Cpu\GD32F4xx; ..\..\app\Module\SmLib; ..\..\app\Module\MPara\lib; ..\..\app\Module\Sample; ..\..\app\System\RTT; ..\..\mbedtls\configs; ..\..\mbedtls\include; ..\..\mbedtls\include\mbedtls; ..\..\mbedtls\library; ..\..\app\Module\MPara\lib; packages\SEGGER_RTT-latest\adapter; packages\SEGGER_RTT-latest\RTT; ..\..\app\System; ..\..\app\Module\sysEvent; ..\..\app\Module\Algo; ..\..\app\Module\ExpFunc; ..\..\app\System\RootTask; ..\..\app\Module\WaveRecord\FatFs_R0.09\src; ..\..\app\Module\WaveRecord\FatFs_R0.09\src\option; ..\..\app\Module\WaveRecord\SDIO; ..\..\app\Module\WaveRecord\SDIO\sd_card\inc; ..\..\app\Module\WaveRecord
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NILM.bin
  ILINK.IlinkOutputFile: GD32F450Z_EVAL.out
  ILINK.IlinkIcfFile: gd32_rom.icf
  ILINK.IlinkAdditionalLibs: ..\..\app\Module\SmLib\libsm4.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F470xI GD GD32F470xI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; __RTTHREAD__; USE_STDPERIPH_DRIVER; GD32F450
  ICCARM.CCIncludePath2: ..\..\include; Libraries\GD32F4xx_standard_peripheral\Include; ..\..\libcpu\arm\common; ..\..\components\drivers\include; ..\..\components\dfs\filesystems\devfs; ..\..\components\libc\posix\ipc; drivers; ..\..\components\net\lwip\lwip-2.0.3\src\include\netif; Libraries\CMSIS\GD\GD32F4xx\Include; .; ..\..\components\net\lwip\lwip-2.0.3\src\include; ..\..\libcpu\arm\cortex-m4; Libraries\CMSIS; ..\..\components\net\sal\include\dfs_net; ..\..\components\dfs\include; ..\..\components\libc\compilers\common\include; applications; ..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4; ..\..\components\net\lwip\port; ..\..\components\finsh; ..\..\components\net\sal\include\socket\sys_socket; ..\..\components\dfs\filesystems\elmfat; ..\..\components\libc\compilers\common\extension; ..\..\components\net\sal\include; ..\..\components\net\sal\impl; ..\..\components\net\netdev\include; ..\..\components\libc\posix\io\poll; ..\..\components\libc\posix\io\stdio; ..\..\components\net\sal\include\socket
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: FHSysmodule.bin
  ILINK.IlinkOutputFile: project.out
  group app/CommAPI
    ../../app/CommAPI/: CommFunc.c CommFunc_API.h crc16.c crc16.h
  group app/Config
    ../../app/Config/: sys.h
  group app/Module/Algo
    ../../app/Module/Algo/: Algorithm.c eb_Processing.c eb_Thread.c nilm_dbscan.c nilm_FeatureExtraction.c nilm_processing.c nilm_thread.c
  group app/Module/DBase
    ../../app/Module/Dbase/: dbase.c dbase.h
  group app/Module/Events
    ../../app/Module/Events/: event.c event.h event_Api.h event_sub.c
  group app/Module/ExpFunc
    ../../app/Module/ExpFunc/: Exp.c
  group app/Module/fal
    ../../app/Fal/: fal.c fal.h fal_cfg.h fal_def.h fal_flash.c fal_partition.c
  group app/Module/Freeze
    ../../app/Module/Freeze/: Freeze.c Freeze.h Freeze_API.h
  group app/Module/Led
    ../../app/Module/Led/: LED.c LED.h
  group app/Module/Meter
    ../../app/Module/Meter/: main_task.c main_task.h task_update.c task_update.h
  group app/Module/MPara
    ../../app/Module/MPara/: ParaInfo.c
  group app/Module/MPara/lib
    ../../app/Module/MPara/lib/: aes.h check_config.h cipher.h cipher_internal.h config.h gcm1.h platform.h platform_util.h threading.h
  group app/Module/MPara/src
    ../../app/Module/MPara/src/: aes.c cipher.c cipher_wrap.c gcm1.c platform_util.c
  group app/Module/Protocol
    ../../app/Module/Protocol/: FactoryPro645.c Protocol.c Protocol.h
  group app/Module/Protocol/DLT645
    ../../app/Module/Protocol/dlt645/: Dlt645_2007.h dlt645_2007_API.h dlt645_2007APP.c dlt645_2007APPData.c dlt645_2007Link.c Record645.c
  group app/Module/Protocol/DLT698
    ../../app/Module/Protocol/DLT698/: Dlt698_45.h Dlt698_45_API.h Dlt698_45_APP.c DLT698_45APPData.c Dlt698LinkData.c ManageCom.c ParaMeter698.c Record698.c Variable698.c
  group app/Module/Sample
    ../../app/Module/Sample/: datadeal.c datadeal_API.h task_sample.c task_sample.h
  group app/Module/SaveMem
    ../../app/Module/SaveMem/: gd25q64c.c gd25q64c.h M24512.c M24512.h SaveMem.c SaveMem.h savemem_API.h
  group app/Module/smLib
    ../../app/Module/SmLib/: light_sm.h light_sm_int.h sm_api.c sm_api.h sm_task.c sm_task.h
  group app/Module/sysEvent
    ../../app/Module/sysEvent/: sysEvent.c
  group app/Module/Time
    ../../app/Module/Time/: dsp_time.c dsp_time.h
  group app/Module/WaveRecord
    ../../app/Module/WaveRecord/: WaveRecord.c WaveRecord.h
  group app/Module/WaveRecord/Fatfs
    ../../app/Module/WaveRecord/FatFs_R0.09/src/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group app/Module/WaveRecord/SDIO
    ../../app/Module/WaveRecord/SDIO/: SDIO_MSD_Driver.c SDIO_MSD_Driver.h
  group app/Module/WaveRecord/SDIO/sdcard/inc
    ../../app/Module/WaveRecord/SDIO/sd_card/inc/: sdcard.h
  group app/Module/WaveRecord/SDIO/sdcard/src
    ../../app/Module/WaveRecord/SDIO/sd_card/src/: sdcard.c
  group app/System
    ../../app/System/: TaskFun.c TaskFun.h
  group app/System/Board
    ../../app/System/Board/: board_gd32f450.c board_gd32f450.h
  group app/System/Cpu
    ../../app/System/Cpu/GD32F4xx/: cpustm32f4xx.c cpustm32f4xx.h gd32f4xx_it.c gd32f4xx_it.h
    ../../app/System/Cpu/GD32F4xx/GD32F4xx_board/: spi.c spi.h systick.c systick.h tim.c tim.h usart.c usart.h
  group app/System/Flag
    ../../app/System/Flag/: Flag.c flag_API.h
  group app/System/RootTask
    ../../app/System/RootTask/: Root.c
  group Applications
    applications/: main.c
  group bsp/Compiler
    ../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
    ../../components/libc/compilers/dlib/: environ.c syscall_mem.c syscalls.c
  group bsp/CPU
    ../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
    ../../libcpu/arm/common/: div0.c showmem.c
  group bsp/Libraries
    Libraries/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
    Libraries/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f450_470.s
    Libraries/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group rtos/DeviceDrivers
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
  group rtos/DeviceDrivers/Finsh
    ../../components/finsh/: cmd.c msh.c msh_file.c msh_parse.c shell.c
  group rtos/Drivers
    drivers/: board.c drv_exmc_sdram.c drv_usart.c synopsys_emac.c
  group rtos/Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group rtos/SEGGER_RTT
    packages/SEGGER_RTT-latest/adapter/: drv_rtt.c
    packages/SEGGER_RTT-latest/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
